Commit message: 注意该版本不适用于旧版本无按钮talon
修改参数配置文件和urdf的动力学参数,注意该版本不适用于旧版本

File: config/TL20240901/robot.urdf (robot description, URDF)
Before this commit: robot talon, 8 links, 7 joints
Links:
- link link_3: mass 3.685 -> 3.885
- link link_7: mass 0.994 -> 1.194
